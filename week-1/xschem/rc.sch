** sch_path: week-1/xschem/rc.sch
**.subckt rc Vout ref Vin
*.opin Vout
*.iopin ref
*.ipin Vin
R1 Vout Vin 1k m=1
C1 Vout ref 1p m=1
**.ends
.end
